# IAR project libbtdriver.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: SDK_VERSION="V6.0.r7..p1"; _NO_DEFINITIONS_IN_HEADER_FILES; _ENABLE_THREAD_SUPPORT_; MBEDTLS_CONFIG_FILE=<default.h>
  ICCARM.PreInclude: $WS_DIR$\bin\mw300_defconfig\autoconf.h
  ICCARM.CCIncludePath2: $WS_DIR$\.; $WS_DIR$\sdk\src\incl\sdk; $WS_DIR$\sdk\src\incl\sdk\crypto; $WS_DIR$\sdk\src\incl\sdk\drivers; $WS_DIR$\sdk\src\incl\sdk\drivers\mw300; $WS_DIR$\sdk\src\incl\sdk\drivers\mw300\regs; $WS_DIR$\sdk\src\incl\sdk\drivers\wlan; $WS_DIR$\sdk\src\incl\sdk\drivers\bt; $WS_DIR$\sdk\src\incl\libc\iar; $WS_DIR$\sdk\src\boards; $WS_DIR$\sdk\src\incl\ble\include; $WS_DIR$\sdk\src\incl\ble\fp0; $WS_DIR$\sdk\src\middleware\provisioning; $WS_DIR$\sdk\src\middleware\crypto\aescrypto; $WS_DIR$\sdk\src\bt\btdriver; $WS_DIR$\sdk\src\incl\platform\os\freertos; $WS_DIR$\sdk\external\freertos\Source\include\; $WS_DIR$\sdk\external\freertos\; $WS_DIR$\sdk\external\freertos\Source\portable\IAR\ARM_CM4F; $WS_DIR$\sdk\src\incl\platform\net\lwip; $WS_DIR$\sdk\external\lwip\src\include\; $WS_DIR$\sdk\external\lwip\src\include\ipv4; $WS_DIR$\sdk\external\lwip\src\include\ipv6; $WS_DIR$\sdk\external\lwip\contrib\port\FreeRTOS\wmsdk\; $WS_DIR$\sdk\external\nghttp2\lib\includes; $WS_DIR$\sdk\external\usb-host\incl; $WS_DIR$\sdk\external\opus\include; $WS_DIR$\sdk\external\aws_iot\include; $WS_DIR$\sdk\external\mbedtls\upstream\include; $WS_DIR$\sdk\external\mbedtls\port; $WS_DIR$\sdk\external\mbedtls\helper_api; $WS_DIR$\sdk\external\mbedtls\config; $WS_DIR$\sdk\src\incl\libc; $WS_DIR$\sdk\src\bt\btdriver
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: libbtdriver.a
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG; SDK_VERSION="V6.0.r7..p1"; _NO_DEFINITIONS_IN_HEADER_FILES; _ENABLE_THREAD_SUPPORT_; MBEDTLS_CONFIG_FILE=<default.h>
  ICCARM.CCOptStrategy: 0
  group (top)
    $WS_DIR$/sdk/src/bt/btdriver/: bt.c bt_uart_common.c
